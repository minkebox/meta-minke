FILESEXTRAPATHS_prepend := "${THISDIR}/linux:"

SRC_URI += "file://docker.cfg file://cpu.cfg"

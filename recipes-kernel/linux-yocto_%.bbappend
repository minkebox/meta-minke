FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://docker.cfg file://minipc.cfg"
